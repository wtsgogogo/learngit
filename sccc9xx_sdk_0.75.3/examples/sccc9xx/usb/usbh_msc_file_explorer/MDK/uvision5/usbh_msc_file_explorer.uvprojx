# Keil uVision project usbh_msc_file_explorer.uvprojx, settings and files
target usbh_msc_file_explorer (ARM-ADS)
  device: sccc9xx Sgchip
  pack: Sgchip.sccc9xx.DFP.1.0.0
  cpu: IROM(0x00800000,0x00100000) IRAM(0x20001000,0x00001000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: usbh_msc_file_explorer
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=5 v6LangP=4
  c define: SCCC9XX, CFG_TUSB_MCU=OPT_MCU_SCCC9XX
  c include: ..\..; ..\..\..\..\..\..\module\tinyusb\examples\host\msc_file_explorer\src; ..\..\..\..\..\..\module\fatfs\source; ..\..\..\..\..\..\module\embedded-cli; ..\..\..\..\..\..\hal_driver\inc; ..\..\..\..\..\..\hal_driver\api; ..\..\..\..\..\..\module\common; ..\..\..\..\..\..\module\debug; ..\..\..\..\..\..\module\debug\RTT; ..\..\..\..\..\..\soc; ..\..\..\..\..\..\soc\arm_cm; ..\..\..\..\..\..\soc\arm_cm\cmsis; ..\..\..\..\..\..\soc\arm_cm\sccc9xx; ..\..\..\..\..\..\module\tinyusb\src; ..\..\..\..\..\..\module\tinyusb\src\common; ..\..\..\..\..\..\module\tinyusb\src\device; ..\..\..\..\..\..\module\tinyusb\src\host; ..\..\..\..\..\..\module\tinyusb\src\osal; ..\..\..\..\..\..\module\tinyusb\hw
  asm misc: -DSCCC9XX -DCFG_TUSB_MCU=OPT_MCU_SCCC9XX
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: ..\..\..\..\..\..\soc\arm_cm\sccc9xx\compiler\armcc\link_script.txt
  link misc: --datacompressor=off --diag_suppress=L6314,L6329 ..\..\..\..\..\..\soc/arm_cm\sccc9xx\compiler/armcc/rom_sym.txt
  group default
    ../../: app_config.h
    ../../../../../../soc/arm_cm/cmsis/: arm_common_tables.h arm_const_structs.h arm_math.h cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
    ../../../../../../module/common/: async_call.h circular_doubly_linked_list.h co_error.h co_list.h co_math.h common.h linked_async_framework.h sw_timer.h sw_timer_int.h
    ../../../../../../hal_driver/api/: calc_div.h hal_adc.h hal_adcv2.h hal_cache.h hal_can.h hal_comp.h hal_crc.h hal_crypt.h hal_dac.h HAL_def.h hal_dmac.h hal_dmacv2.h hal_ecc.h hal_flash.h hal_i2c.h hal_iwdg.h hal_iwdgv2.h hal_patch.h hal_pdm.h hal_pis.h hal_rtc.h hal_rtcv2.h hal_sha.h hal_sm4.h hal_spi_i2s.h hal_ssi.h hal_timer.h hal_touchkey.h hal_trng.h hal_uart.h hal_wwdg.h ll_i2c.h ll_opamp.h ll_spi.h ll_ssi.h ll_timer.h ll_uart.h
    ../../../../../../soc/: compile_flag.h cpu.h field_manipulate.h sdk_config.h systick.h
    ../../../../../../module/debug/: dbg.h log.h
    ../../../../../../module/tinyusb/src/device/: dcd.h usbd.h usbd_pvt.h
    ../../../../../../module/fatfs/source/: diskio.h ff.h ffconf.h
    ../../../../../../soc/arm_cm/sccc9xx/: dmac_config.h msp_adc.h msp_cache.h msp_can.h msp_comp.h msp_crc.h msp_crypt.h msp_dac.h msp_dmacv2.h msp_ecc.h msp_i2c.h msp_iwdg.h msp_pdm.h msp_pis.h msp_qspiv2.h msp_rtc.h msp_sha.h msp_sm4.h msp_spi_i2s.h msp_ssi.h msp_timer.h msp_touchkey.h msp_trngv2.h msp_uart.h msp_usb.h msp_wwdg.h per_func_mux.h pis_config.h platform.h portmacro.h qspiv2_config.h reg_base_addr.h reg_exti_type.h reg_lstim_type.h reg_sysc_awo_type.h reg_sysc_cpu_type.h reg_sysc_per_type.h reg_v33_rg_type.h sccc9xx.h sdk_default_config.h sleep.h soc_gpio.h soc_pinmux.h sw_timer_port.h sys_stat.h
    ../../../../../../module/embedded-cli/: embedded_cli.h
    ../../../../../../hal_driver/inc/: hal_flash_int.h hal_qspi.h hal_qspiv2.h i2c_misc.h musb_type.h reg_adc_type.h reg_adcv2_type.h reg_cache_type.h reg_calc_crc_type.h reg_calc_type.h reg_can_type.h reg_comp_type.h reg_crypt_type.h reg_dac_type.h reg_dmac_type.h reg_dmacv2_type.h reg_ecc_type.h reg_i2c_type.h reg_iwdg_type.h reg_iwdgv2_type.h reg_lcd_type.h reg_patch_type.h reg_pdm_type.h reg_pis_type.h reg_qspi_type.h reg_qspiv2_type.h reg_rtc_type.h reg_rtcv2_type.h reg_sha_type.h reg_sm4_type.h reg_spi_type.h reg_ssi_type.h reg_timer_type.h reg_touchkey_type.h reg_trng_type.h reg_trngv2_type.h reg_uart_type.h reg_usb_type.h reg_wwdg_type.h ssi_misc.h
    ../../../../../../module/tinyusb/src/host/: hcd.h hub.h usbh.h usbh_classdriver.h
    ../../../../../../soc/arm_cm/: instructions.h swint_call_asm.h
    ../../../../../../module/tinyusb/src/osal/: osal.h osal_freertos.h osal_mynewt.h osal_none.h osal_pico.h osal_rtthread.h osal_rtx4.h
    ../../../../../../module/debug/RTT/: SEGGER_RTT.h SEGGER_RTT_Conf.h
    ../../../../../../module/tinyusb/src/: tusb.h tusb_option.h
    ../../../../../../module/tinyusb/src/common/: tusb_common.h tusb_compiler.h tusb_debug.h tusb_fifo.h tusb_mcu.h tusb_private.h tusb_timeout.h tusb_types.h tusb_verify.h
    ../../../../../../module/tinyusb/examples/host/msc_file_explorer/src/: tusb_config.h
  group examples
    ../../../: bsp.c
  group hal_driver
    ../../../../../../hal_driver/src/: hal_adcv2.c hal_adcv2_dma.c hal_cache.c hal_can.c hal_comp.c hal_crc.c hal_crypt.c hal_dac.c hal_dac_dma.c hal_dmacv2.c hal_ecc.c hal_flash.c hal_flash_qspiv2.c hal_flash_swint.c hal_i2c.c hal_i2c_dma.c hal_iwdgv2.c hal_pdm.c hal_pis.c hal_qspiv2.c hal_rtcv2.c hal_sha.c hal_sm4.c hal_spi_i2s.c hal_spi_i2s_dma.c hal_ssi.c hal_ssi_dma.c hal_timer.c hal_touchkey.c hal_trngv2.c hal_uart.c hal_uart_dma.c hal_wwdg.c tusb_dcd.c tusb_hcd.c
  group module
    ../../../../../../module/tinyusb/src/class/audio/: audio_device.c
    ../../../../../../module/tinyusb/src/class/bth/: bth_device.c
    ../../../../../../module/tinyusb/src/class/cdc/: cdc_device.c cdc_host.c cdc_rndis_host.c
    ../../../../../../module/common/: circular_doubly_linked_list.c common.c
    ../../../../../../module/debug/: dbg.c log.c
    ../../../../../../module/tinyusb/src/class/dfu/: dfu_device.c dfu_rt_device.c
    ../../../../../../module/tinyusb/src/class/net/: ecm_rndis_device.c ncm_device.c
    ../../../../../../module/fatfs/source/: ff.c ffsystem.c ffunicode.c
    ../../../../../../module/tinyusb/src/class/hid/: hid_device.c hid_host.c
    ../../../../../../module/tinyusb/src/host/: hub.c usbh.c
    ../../../../../../module/tinyusb/examples/host/msc_file_explorer/src/: main.c msc_app.c
    ../../../../../../module/tinyusb/src/class/midi/: midi_device.c
    ../../../../../../module/tinyusb/src/class/msc/: msc_device.c msc_host.c
    ../../../../../../module/debug/RTT/: SEGGER_RTT.c
    ../../../../../../module/tinyusb/src/: tusb.c
    ../../../../../../module/tinyusb/src/common/: tusb_fifo.c
    ../../../../../../module/tinyusb/src/device/: usbd.c usbd_control.c
    ../../../../../../module/tinyusb/src/class/usbtmc/: usbtmc_device.c
    ../../../../../../module/tinyusb/src/class/vendor/: vendor_device.c vendor_host.c
    ../../../../../../module/tinyusb/src/class/video/: video_device.c
  group soc
    ../../../../../../soc/arm_cm/sccc9xx/: __info_array.c cpu.c msp_adc.c msp_cache.c msp_can.c msp_comp.c msp_crc.c msp_crypt.c msp_dac.c msp_dmacv2.c msp_ecc.c msp_i2c.c msp_iwdg.c msp_pdm.c msp_pis.c msp_qspiv2.c msp_rtc.c msp_sha.c msp_sm4.c msp_spi_i2s.c msp_ssi.c msp_timer.c msp_touchkey.c msp_trngv2.c msp_uart.c msp_usb.c msp_wwdg.c platform.c rom_flash_api_wrapper.c sleep.c soc_gpio.c sw_timer_port.c sys_stat.c
    ../../../../../../soc/arm_cm/sccc9xx/compiler/armcc/: delay_asm.S sleep_asm.S startup.c startup_asm.S swint_asm.S
    ../../../../../../soc/arm_cm/: systick.c
